# Enable downstream autobump
# The URI is required for the autobump script but keep it commented
# to not override the upstream value
# SRC_URI = "git://github.com/openbmc/pam-ipmi;branch=master;protocol=https"
SRCREV = "ee3d6e81090cc258a181c85f1cc7eb3ac1362270"

