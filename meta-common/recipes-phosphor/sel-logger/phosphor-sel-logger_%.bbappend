# Enable downstream autobump
# The URI is required for the autobump script but keep it commented
# to not override the upstream value
# SRC_URI = "git://github.com/openbmc/phosphor-sel-logger.git;branch=master;protocol=https"
SRCREV = "3c6b9c3a873f7624a6bbf6ebb10482d7a167c0a6"

